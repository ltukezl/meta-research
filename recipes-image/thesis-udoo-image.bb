SUMMARY = "bootstrap"

require recipes-udoo/images/udoo-image-full-cmdline.bb
IMAGE_INSTALL += "gitprog"
