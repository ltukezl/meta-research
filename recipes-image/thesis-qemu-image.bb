SUMMARY = "bootstrap"

require recipes-core/images/core-image-minimal.bb
IMAGE_INSTALL += "gitprog gitmodule progtuomo giti2c rprov"
