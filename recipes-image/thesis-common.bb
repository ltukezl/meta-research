LICENSE = "closed"
IMAGE_INSTALL += "gitprog gitmodule"